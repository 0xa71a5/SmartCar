<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>camera</name>
    <file>
      <name>$PROJ_DIR$\User\DEV_SCCB.c</name>
    </file>
  </group>
  <group>
    <name>Device</name>
    <file>
      <name>$PROJ_DIR$\Libraries\Device\IAR-ARM\startup_MK60D10.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Device\system_MK60D10.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\cmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\cpuidy.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\enet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\flexbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\nfc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\pdb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\tsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\vref.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\Driver\src\wdog.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\User\img_processing.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Libraries\camera\src\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\User\varieble.c</name>
    </file>
  </group>
</project>


